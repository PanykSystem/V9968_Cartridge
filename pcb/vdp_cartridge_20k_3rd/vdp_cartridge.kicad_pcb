# Repository PanykSystem/V9968_Cartridge

File readme.md:

# 概要
MSX2++用のVDP「V9968」の開発用リポジトリです。

# LICENSE
MIT License

# 残件
- ~~HDMI対応 (現状は DVI）~~ PLLが足りず HDMI用のクロックが作れないため DVI 720x480 で確定
- メニューなどを表示するためのモノクロオーバーレイビットマップ表示機能

# 免責事項
自動車等の乗り物や、医療、軍事等、人命にかかわるようなものへ、
一部または全部を転用する行為は厳禁です。

## KiCad design pcb/vdp_cartridge_20k_3rd/vdp_cartridge.kicad_pcb

Parts:
C1: 100uF; C_1210_3225Metric; LCSC C49066
C2, C4, C5, C6, C7, C8, C9: 0.1uF; C_0402_1005Metric; LCSC C1525
C3: 15pF; C_0805_2012Metric; LCSC C63339
J1: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
JP1, JP2: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Horizontal
Q1, Q2, Q3: NMOS; MOSFET(SMD); LCSC C2589
R2: 10kΩ; R_0805_2012Metric; LCSC C17414
R4, R5: 3.3kΩ; R_0805_2012Metric; LCSC C26010
U1: CLOCK; LCSC C2901565
U2: TangNano20K
U3: MSX Cartridge_1
U4, U5, U6: SSOP-24_5.3x8.2mm_P0.65mm; LCSC C19197

Connections:
3V3: C2.1, C4.1, C6.1, C8.1, J1.1, JP1.1 (A), JP2.1 (A), R5.1, U1.4 (3V3), U2.19 (3V3), U4.1 (VCCA), U5.1 (VCCA), U6.1 (VCCA)
5V: C1.1, C5.1, C7.1, C9.1, U2.40 (5V), U3.45 (+5V), U3.47 (+5V), U4.23 (VCCB), U4.24 (VCCB), U5.23 (VCCB), U5.24 (VCCB), U6.23 (VCCB), U6.24 (VCCB)
A0: U3.28 (A0), U5.21 (B1)
A1: U3.27 (A1), U5.20 (B2)
A2: U3.30 (A2), U5.19 (B3)
A3: U3.29 (A3), U5.18 (B4)
A4: U3.32 (A4), U5.17 (B5)
A5: U3.31 (A5), U5.16 (B6)
A6: U3.22 (A6), U5.15 (B7)
A7: U3.21 (A7), U5.14 (B8)
CLOCK: C3.1, U1.3 (CLK), U2.37 (IOT27A(80):SDIO_D2)
D0: U3.34 (D0), U4.21 (B1)
D1: U3.33 (D1), U4.20 (B2)
D2: U3.36 (D2), U4.19 (B3)
D3: U3.35 (D3), U4.18 (B4)
D4: U3.38 (D4), U4.17 (B5)
D5: U3.37 (D5), U4.16 (B6)
D6: U3.40 (D6), U4.15 (B7)
D7: U3.39 (D7), U4.14 (B8)
DIPSW0: JP1.2 (B), U2.22 (IOR38B(53))
DIPSW1: JP2.2 (B), U2.21 (IOR39A(52))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.2, Q1.3 (S), Q2.3 (S), Q3.3 (S), R2.2, R4.2, U1.2 (GND), U2.20 (GND), U2.26 (GND), U2.39 (GND), U3.41 (GND), U3.43 (GND), U4.11 (GND), U4.12 (GND), U4.13 (GND), U5.2 (DIR), U5.11 (GND), U5.12 (GND), U5.13 (GND), U6.2 (DIR), U6.11 (GND), U6.12 (GND), U6.13 (GND), U6.14 (B8), U6.16 (B6), U6.18 (B4), U6.20 (B2)
I2S_BCLK: J1.5, U2.34 (IOR36A(56))
I2S_DIN: J1.4, U2.33 (IOR38A(54))
I2S_EN: J1.6, U2.32 (IOR45A(51))
I2S_LRCLK: J1.3, U2.30 (IOR36B(55))
unnamed: U3.44 (SW1), U3.46 (SW2)
SLOT_A0: U2.13 (IOB14B(30)), U5.3 (A1)
SLOT_A1: U2.14 (IOB29A(31)), U5.4 (A2)
SLOT_A2: U2.38 (IOT30B(76)), U5.5 (A3)
SLOT_A3: U2.36 (IOB42B(42)), U5.6 (A4)
SLOT_A4: U2.35 (IOB43A(41)), U5.7 (A5)
SLOT_A5: U2.31 (IOR49B(48)), U5.8 (A6)
SLOT_A6: U2.29 (IOR49A(49)), U5.9 (A7)
SLOT_A7: U2.15 (IOL49A(17)), U5.10 (A8)
SLOT_D0: U2.12 (IOB14A(29)), U4.3 (A1)
SLOT_D1: U2.9 (IOB8B(28)), U4.4 (A2)
SLOT_D2: U2.8 (IOB8A(27)), U4.5 (A3)
SLOT_D3: U2.5 (IOT30A(77)), U4.6 (A4)
SLOT_D4: U2.4 (IOT4B(85):SDIO_D1), U4.7 (A5)
SLOT_D5: U2.3 (IOT34A(75)), U4.8 (A6)
SLOT_D6: U2.2 (IOT34B(74)), U4.9 (A7)
SLOT_D7: U2.1 (IOT40A(73)), U4.10 (A8)
SLOT_DATA_DIR: Q1.2 (G), R2.1, U2.17 (IOL51A(19)), U4.2 (DIR)
SLOT_INT: Q3.2 (G), R4.1, U2.23 (IOT44A(71))
SLOT_IORQ_N: U2.18 (IOL49B(18)), U6.3 (A1)
SLOT_OE_N: U2.16 (IOL51B(20)), U4.22 (OEn), U5.22 (OEn), U6.22 (OEn)
SLOT_RD_N: U2.6 (IOL47A(15)), U6.7 (A5)
SLOT_RESET_N: U2.28 (IOT4A(86)), U6.9 (A7)
SLOT_WAIT: Q2.2 (G), R5.2, U2.24 (IOT40B(72))
SLOT_WR_N: U2.7 (IOT47B(16)), U6.5 (A3)
/BUSDIR: Q1.1 (D), U3.10 (/BUSDIR)
/INT: Q3.1 (D), U3.8 (/INT)
/IORQ: U3.11 (/IORQ), U6.21 (B1)
/RD: U3.14 (/RD), U6.17 (B5)
/RESET: U3.15 (/RESET), U6.15 (B7)
/WAIT: Q2.1 (D), U3.7 (/WAIT)
/WR: U3.13 (/WR), U6.19 (B3)

Notes on the sheet:
I/O SELECT 0: 88h (OPEN) 1: 98h（SHORT）
SLOT_INT : 1 → /INT=0 0 or HiZ → /INT=HiZ
TO236AB Vgs(th) = 1.25V
En は、OPEN か H で CLK を出力、L で CLK が HiZ になる。
TangNano20K
BUSDIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
14.318180MHz
※正論理
SLOT_DATA_DIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
SLOT_WAIT : 1 or HiZ → /WAIT=0 0 → /WAIT=HiZ
SN74LVC8T245DBR 24SSOP
FORCE HIGHSPEED 0: NORMAL（OPEN） 1: HIGHSPEED（SHORT）
/BUSDIR 1: CPU → Cartridge (WRITE) 0: CPU ← Cartridge (READ)

Board: 2 copper layers, 95.2 x 65.4 mm, 26 parts (0 on the bottom side), 58 nets.

Other parts of the board:
G1: LOGO; usa_10x7
G3: LOGO; msx_logo_15x5p8

File pcb/vdp_cartridge_20k_3rd/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,1210,1,100uF,C49066
"C2, C4, C5, C6, C7, C8, C9",0402,7,0.1uF,C1525
C3,0805,1,15pF,C63339
"Q1, Q2, Q3",MOSFET(SMD),3,NMOS,C2589
R2,0805,1,10kΩ,C17414
"R4, R5",0805,2,3.3kΩ,C26010
U1,CLOCK,1,~,C2901565
"U4, U5, U6",SSOP-24_5.3x8.2mm_P0.65mm,3,~,C19197

Notices in the files:
pcb/vdp_cartridge_20k_3rd/vdp_cartridge.kicad_pcb:
Copyright 2026 HRA!
